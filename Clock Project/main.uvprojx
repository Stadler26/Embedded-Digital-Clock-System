# Keil uVision project main.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: main
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Source Group 1
    ./: main.c app_fsm.c app_fsm.h uart_display.c uart_display.h rgb_led.c rgb_led.h buzzer.c buzzer.h adc_pot.c adc_pot.h timer_clock.c timer_clock.h gpio_keypad.c gpio_keypad.h eeprom_store.c eeprom_store.h snooze.c snooze.h idle.c idle.h
software components: CMSIS:CORE 6.2.0, Device:Startup 1.0.0
